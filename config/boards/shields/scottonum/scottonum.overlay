/ {
    chosen {
        zmk,kscan = &kscan;
    };

    kscan: kscan {
        compatible = "zmk,kscan-gpio-direct";
        label = "KSCAN";
        rows = <1>;
        columns = <1>;

        &kscan {
            input-gpios =
                <&pro_micro 20 (GPIO_ACTIVE_LOW | GPIO_PULL_UP)>
            };
        };
    };
};